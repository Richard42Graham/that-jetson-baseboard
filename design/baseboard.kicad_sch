File: design/baseboard.kicad_sch (KiCad schematic)
At the start: 10 parts

Commit message: cleaned up a bit, more to do
Parts:
- R21, R22, R23: now not fitted; now left out of the parts list
